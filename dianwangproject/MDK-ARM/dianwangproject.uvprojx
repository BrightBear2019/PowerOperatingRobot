# Keil uVision project dianwangproject.uvprojx, settings and files
target dianwangproject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dianwangproject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../User/ioLibrary_Driver/Ethernet;../User/ioLibrary_Driver/Ethernet/W5500;../User/ioLibrary_Driver/Internet/DHCP;../User/Loopback;../User/wiz_interface;../User/wiz_platform;../User/user_main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: modbusCRC.c main.c gpio.c dma.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Ethernet
    ../User/ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../User/ioLibrary_Driver/Ethernet/W5500/: w5500.c w5500.h
  group Internet
    ../User/ioLibrary_Driver/Internet/DHCP/: dhcp.c dhcp.h
  group User
    ../User/Loopback/: loopback.c loopback.h
    ../User/user_main/: user_main.c user_main.h
    ../User/wiz_interface/: wiz_interface.c wiz_interface.h
    ../User/wiz_platform/: wiz_platform.c wiz_platform.h
software components: CMSIS:CORE 4.3.0
